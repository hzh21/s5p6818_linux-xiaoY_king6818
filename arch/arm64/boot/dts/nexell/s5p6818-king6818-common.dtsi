/*
 * (C) Copyright 2026 Optimized for RongPin King6818
 * Based on FriendlyElec S5P6818 DTS
 */

/memreserve/ 0x7de00000 0x00100000; /* OP-TEE SHM */
#include <dt-bindings/interrupt-controller/irq.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/input/input.h>
#include "s5p6818.dtsi"

#define PMIC_PDATA_INIT(_id, _rname, _minuv, _maxuv,	\
						_always_on, _boot_on, _init_uv,	\
						_init_enable, _slp_slots)		\
		regulator-name = _rname;			\
		regulator-min-microvolt = <_minuv>;	\
		regulator-max-microvolt = <_maxuv>;	\
		nx,id = <_id>;						\
		nx,always_on = <_always_on>;		\
		nx,boot_on = <_boot_on>;			\
		nx,init_enable = <_init_enable>;	\
		nx,init_uV = <_init_uv>;			\
		nx,sleep_slots = <_slp_slots>;

/ {
	model = "RongPin king6818";
	compatible = "RongPin,king6818", "nexell,s5p6818";

	memory {
		device_type = "memory";
		/* 即使 U-Boot 只认 1GB，这里先声明 2GB 布局 */
		reg = <0x00000000 0x40000000 0x00000000 0x80000000>;
	};

	aliases {
		ethernet0 = &gmac0;
	};

	soc {
		#include "s5p6818-pinctrl.dtsi"

		/* 修正 CPU 调频：仅指向 AXP 供电，删除不存在的 SPU 引用 */
		dvfs:dynamic-freq@bb000 {
			supply_name = "vdd_arm_axp";
			vdd_arm_axp-supply = <&VCC1P1_ARM_PMIC>;
			status = "okay";
			dvfs-tables = <1400000 1250000
						   1200000 1150000
						   1000000 1100000
						   800000  1050000
						   400000  1000000>;
		};

		/* 关键修正：模拟 I2C 总线 3 适配荣品 D2/D3 引脚 */
		i2c3_gpio:i2c@3 {
			compatible = "i2c-gpio";
			gpios = <&gpio_d 3 0	/* sda -> GPIOD3 (99) */
				     &gpio_d 2 0	/* scl -> GPIOD2 (98) */
				>;
			i2c-gpio,delay-us = <20>; /* 约 25kHz，增加稳定性 */
			#address-cells = <1>;
			#size-cells = <0>;
			status = "okay";

			axp228@34 {
				compatible = "x-powers,axp228";
				reg = <0x34>;
				interrupt-parent = <&alive_0>;
				interrupts = <4 IRQ_TYPE_LEVEL_LOW>;
				nx,id = <0>;

				regulators {
					VCC_LDO1:  axp22_rtcldo { PMIC_PDATA_INIT( 0, "axp228_rtcldo", 3000000, 3000000, 0, 0, 3300000, 0, 0xF) };
					VCC_LDO2:  axp22_aldo1  { PMIC_PDATA_INIT( 1, "axp228_3p3_alive", 3300000, 3300000, 1, 1, 3300000, 1, 0xF) };
					VCC_LDO3:  axp22_aldo2  { PMIC_PDATA_INIT( 2, "axp228_1p8_alive", 1800000, 1800000, 1, 1, 1800000, 1, 0xF) };
					VCC_LDO10: axp22_eldo2  { 
						/* WiFi 供电：强制开机常开 */
						PMIC_PDATA_INIT( 9, "axp228_3p3_wifi", 3300000, 3300000, 1, 1, 3300000, 1, 0xF) 
						regulator-always-on;
						regulator-boot-on;
					};
					VCC_DCDC1: axp22_dcdc1  { PMIC_PDATA_INIT(12, "axp228_3p3_sys", 3300000, 3300000, 1, 1, 3300000, 1, 0xF) };
					VCC1P1_ARM_PMIC: axp22_dcdc2 { PMIC_PDATA_INIT(13, "axp228_1p1_arm", 1100000, 1300000, 1, 1, 1100000, 1, 0xF) };
					VCC_DCDC5: axp22_dcdc5  { 
						/* 内存供电：2GB 必须锁定 1.5V */
						PMIC_PDATA_INIT(16, "axp228_1p5_ddr", 1500000, 1500000, 1, 1, 1500000, 1, 0xF) 
						regulator-always-on;
					};
				};
			};
		};
		mach: board {
        compatible = "friendlyelec,board";
        machine = "NANOPI3";
        hwrev = <255>;
        model = "NanoPi 3 Series";
    };

    /* 必须补上这部分，否则 &simple_card 会报错 */
    simple_card: sound {
        compatible = "nexell,simple-audio-card";
        simple-audio-card,name = "nanopi3-audio";
        status = "okay";
        /* 内部 dai-link 先留空或按之前配置写 */
    };
    
    /* 如果报错里还有 panel，也补上这个 */
    panel: panel-friendlyelec {
        compatible = "lcds";
        status = "okay";
        port { lcd_panel: endpoint { }; };
    };
		/* 其余外设基本保持默认，仅确保串口正常 */
		serial0:serial@c00a1000 { status ="okay"; };
		dw_mmc_0:dw_mmc@c0062000 { status = "okay"; };
		gmac0:ethernet@c0060000 {
			pinctrl-names = "default";
			pinctrl-0 = <&gmac_pins>;
			status = "okay";
			#address-cells = <0x1>;
			#size-cells = <0x0>;
			snps,phy-addr = <4>;
			snps,reset-gpio = <&gpio_e 22 0>;
			snps,reset-active-low;
			snps,reset-delays-us = <0 10000 30000>;
			mdio {
				#address-cells = <1>;
				#size-cells = <0>;
				ethernet_phy: ethernet-phy@4 {
					reg = <4>;
					fixed-link { speed = <1000>; full-duplex; };
				};
			};
		};
	};

	/* 修正 WiFi 节点：与 AXP 供电解耦或强绑定 */
	wlan {
		compatible = "samsung,brcm-wlan";
		vmmc-supply = <&VCC_LDO10>;
		gpios = <&gpio_b 24 0 &gpio_c 17 0>;
		status = "okay";
	};
};
